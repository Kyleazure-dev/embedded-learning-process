# Keil uVision project LCD1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LCD1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: E:\STC89C51\AFunctionBase
  group Source Group 1
    ./: STARTUP.A51 main.c
    ../AFunctionBase/: Seg.c Seg.h LCD1602.h LCD1602.c Delay.h Delay.c
